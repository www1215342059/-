# Keil uVision project 鞋柜主控.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 鞋柜主控 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP;..\..\鞋柜主控;..\APP\ADC;..\APP\Eeprom;..\APP\Fingerprint;..\APP\System;..\APP\System;..\APP\Uart;..\APP\WIFI;..\APP\LCD;..\APP\SPI;..\APP\GUI;..\APP\Time;..\APP\H
  group User
    ../User/: main.c
    ../APP/: mystring.c
  group ADC
    ../APP/ADC/: Adc.c
  group Eeprom
    ../APP/Eeprom/: Eeprom.c
  group WIFI
    ../APP/WIFI/: WIFI.c
  group Fingerprint
    ../APP/Fingerprint/: Fingerprint.c
    ../APP/H/: mystring.h
  group Uart
    ../APP/Uart/: Uart.c
  group System
    ../APP/System/: System.c
  group LCD
    ../APP/LCD/: ST7789V.c
  group SPI
    ../APP/SPI/: SPI.c
  group GUI
    ../APP/GUI/: GUI.c
  group Time
    ../APP/Time/: Time.c
